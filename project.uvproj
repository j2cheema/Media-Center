# Keil uVision project project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: project
  c flags: Optim=1
  c include: .\common\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: startup_LPC17xx.s ADC.c adcuser.c Blinky.c core_cm3.c GLCD_SPI_LPC1700.c IRQ.c KBD.c LED.c system_LPC17xx.c usbcore.c usbdesc.c usbdmain.c usbhw.c usbuser.c ADC.h adcuser.h audio.h core_cm3.h Font_6x8_h.h Font_16x24_h.h GLCD.h KBD.h LED.h LPC17xx.h system_LPC17xx.h type.h usb.h usbaudio.h usbcfg.h usbcore.h usbdesc.h usbhw.h usbreg.h usbuser.h nike.c ball..c logo.c
